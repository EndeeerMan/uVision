# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: C:\Keil_v5\C51\INC\STC
  group Source Group 1
    ./: STARTUP.A51 Main.c LCD1602.c LCD1602.h Board_DS1302.c Board_DS1302.h
