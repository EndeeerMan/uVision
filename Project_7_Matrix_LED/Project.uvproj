# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: C:\Keil_v5\C51\INC\STC
  group Source Group 1
    ./: Main.c STARTUP.A51 Board_LED_74595HC.c Board_LED_74595HC.h
